# Keil uVision project GPS_TRACKING.uvprojx, settings and files
target GPS_TRACKING (ARM-ADS)
  device: ??device?? STMicroelectronics
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  group 
    ./: 
software components: CMSIS:CORE 4.3.0
